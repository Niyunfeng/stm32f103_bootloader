# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\src\sys\delay;..\src\sys\pub;..\src\sys\uart;..\src\sys\led
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../src/app/: main.c bsp.c
  group sys
    ../src/sys/pub/: pub.c
    ../src/sys/delay/: delay.c
    ../src/sys/uart/: uart.c
    ../src/sys/led/: led.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
